# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.20
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F002Bx5
  c include: ..\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\PY32F002B_HAL_Driver\Inc;..\Drivers\PY32F002B_HAL_Driver\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ../Src/: system_py32f002b.c
    ./: startup_py32f002bxx.s
  group Application/User
    ../Src/: main.c py32f002b_it.c key_driver.c led_driver.c mode_led_driver.c unit_led_driver.c pressure_display_driver.c display_control_driver.c battery_icon_driver.c dc_led_driver.c option_bytes_driver.c uart_halfduplex_driver.c uart_protocol_driver.c uart_command_driver.c
    ../Inc/: py32_u1_hw_config.h key_driver.h led_driver.h mode_led_driver.h unit_led_driver.h pressure_display_driver.h display_control_driver.h battery_icon_driver.h dc_led_driver.h option_bytes_driver.h uart_control_driver.h uart_protocol_driver.h uart_command_driver.h
  group Driver
    ../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_comp.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_spi.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c
    ../Drivers/PY32F002B_HAL_Driver/Inc/: py32f0xx_hal.h py32f002b_hal_adc.h py32f002b_hal_comp.h py32f002b_hal_cortex.h py32f002b_hal_crc.h py32f002b_hal_def.h py32f002b_hal_exti.h py32f002b_hal_flash.h py32f002b_hal_gpio.h py32f002b_hal_gpio_ex.h py32f002b_hal_i2c.h py32f002b_hal_lptim.h py32f002b_hal_pwr.h py32f002b_hal_rcc.h py32f002b_hal_rcc_ex.h py32f002b_hal_spi.h py32f002b_hal_tim.h py32f002b_hal_tim_ex.h py32f002b_hal_uart.h py32f002b_hal_usart.h
