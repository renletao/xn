# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.20
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F002Bx5,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\PY32F002B_HAL_Driver\Inc;..\Drivers\PY32F002B_HAL_Driver\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ../Src/: system_py32f002b.c
    ./: startup_py32f002bxx.s
  group Application/User
    ../Src/: main.c py32f002b_it.c adc.c charge.c moto.c ip2326.c usbin.c uart_halfduplex_driver.c uart_protocol_driver.c uart_command_driver.c soft_uart.c wf183d.c led.c
  group Driver
    ../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_comp.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_spi.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c py32f002b_ll_adc.c py32f002b_ll_comp.c py32f002b_ll_crc.c py32f002b_ll_exti.c py32f002b_ll_gpio.c py32f002b_ll_i2c.c py32f002b_ll_lptim.c py32f002b_ll_pwr.c py32f002b_ll_rcc.c py32f002b_ll_spi.c py32f002b_ll_tim.c py32f002b_ll_usart.c py32f002b_ll_utils.c
    ../Drivers/PY32F002B_HAL_Driver/Inc/: py32f0xx_hal.h py32f002b_hal_adc.h py32f002b_hal_comp.h py32f002b_hal_cortex.h py32f002b_hal_crc.h py32f002b_hal_def.h py32f002b_hal_exti.h py32f002b_hal_flash.h py32f002b_hal_gpio.h py32f002b_hal_gpio_ex.h py32f002b_hal_i2c.h py32f002b_hal_iwdg.h py32f002b_hal_lptim.h py32f002b_hal_pwr.h py32f002b_hal_rcc.h py32f002b_hal_rcc_ex.h py32f002b_hal_spi.h py32f002b_hal_tim.h py32f002b_hal_tim_ex.h py32f002b_hal_uart.h py32f002b_hal_usart.h py32f002b_ll_adc.h py32f002b_ll_bus.h py32f002b_ll_comp.h py32f002b_ll_cortex.h py32f002b_ll_crc.h py32f002b_ll_exti.h py32f002b_ll_flash.h py32f002b_ll_gpio.h py32f002b_ll_i2c.h py32f002b_ll_iwdg.h py32f002b_ll_lptim.h py32f002b_ll_pwr.h py32f002b_ll_rcc.h py32f002b_ll_spi.h py32f002b_ll_system.h py32f002b_ll_tim.h py32f002b_ll_usart.h py32f002b_ll_utils.h
